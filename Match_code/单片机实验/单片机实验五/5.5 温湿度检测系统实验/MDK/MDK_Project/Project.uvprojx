# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\Driver\DHT11;..\Driver\LIGHT;..\Driver\LED;..\Driver\USART;..\Driver\TIMER;..\Driver\OLED;..\Driver\SEG;..\Driver\24C02;..\Driver\ADC;..\Driver\BEEP;..\Driver\KEY;..\Driver\JTAG_SW;..\Driver\ESP8266;..\Driver\USART2;..\Driver\MQ2;..\Driver\RELAY;..\Driver\MOTOR;..\Driver\Cloud
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group StdPeriph_Driver
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h delay.c
  group Drive
    ../Driver/JTAG_SW/: jtag_sw.c
    ../Driver/LED/: led.c
    ../Driver/KEY/: key.c
    ../Driver/BEEP/: beep.c
    ../Driver/SEG/: seg.c
    ../Driver/DHT11/: dht11.c
    ../Driver/LIGHT/: light.c
    ../Driver/OLED/: oled.c
    ../Driver/ADC/: adc.c
    ../Driver/24C02/: 24cxx.c
    ../Driver/USART2/: usart2.c
    ../Driver/RELAY/: relay.c
    ../Driver/MQ2/: mq2.c
    ../Driver/MOTOR/: motor.c
  group ESP8266
    ../Driver/ESP8266/: atk_esp8266d.c atk_esp8266d_uart.c
  group Cloud
    ../Driver/Cloud/: IoTMessageHandler.c cloud.c
software components: CMSIS:CORE 5.0.1
